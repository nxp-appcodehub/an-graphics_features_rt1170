<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Map_PXP_LCDIF_SingleTask.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>flexspi_nor_sdram_debug</configuration>
            </member>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>flexspi_nor_sdram_release</configuration>
            </member>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>sdram_debug</configuration>
            </member>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>sdram_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_sdram_debug</name>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>flexspi_nor_sdram_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_sdram_release</name>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>flexspi_nor_sdram_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>sdram_debug</name>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>sdram_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>sdram_release</name>
            <member>
                <project>clock_freertos_cm7</project>
                <configuration>sdram_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
